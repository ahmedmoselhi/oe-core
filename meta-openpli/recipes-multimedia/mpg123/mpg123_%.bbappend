RDEPENDS_${PN} = " libltdl "

inherit upx-compress
