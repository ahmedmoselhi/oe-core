# Get rid of udev dependency
PACKAGECONFIG = ""

inherit upx-compress