require fulan-dvb-modules.inc

PR = "${INC_PR}"

SRCDATE = "20200519"

COMPATIBLE_MACHINE = "spark"
